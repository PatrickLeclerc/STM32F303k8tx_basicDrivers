# Keil uVision project STM32F303k8tx_basicDrivers.uvprojx, settings and files
target STM32f303k8tx (6160000::V6.16::ARMCLANG)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303k8tx_basicDrivers +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group app
    ./: main.c main.h
  group it
    ./: it.c it.h
  group drivers
    ./: drivers.c drivers.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
